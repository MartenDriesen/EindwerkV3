.title Simple Circuit

RR1 N1 0 1.0

VV1 0 N1 10.0
