* Auto-generated SPICE Netlist
R1 2 1 0
C1 1 3 0
.MODEL Dmodel D(IS=1e-14)
.MODEL Qmodel NPN (BF=100)
.MODEL Mmodel NMOS (VTO=2)
.MODEL Zmodel D(BV=5 IBV=0.1m)
.END
